# IAR project TOPAZ MC-21G SOFT v2.0.ewp, settings and files
configuration TOPAZ MC-21G SOFT v2.0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F070CB ST STM32F070CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F070xB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TOPAZ MC-21G SOFT v2.0.hex
  ILINK.IlinkOutputFile: TOPAZ MC-21G SOFT v2.0.out
  ILINK.IlinkIcfFile: stm32f070xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f070xb.s
  group Application/User/Core
    ../Core/Src/: gpio.c i2c.c main.c mdio.c stm32f0xx_hal_msp.c stm32f0xx_it.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_ll_usb.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
