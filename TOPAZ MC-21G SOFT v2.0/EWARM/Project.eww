<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\TOPAZ MC-21G SOFT v2.0.ewp</path>
  </project>
  <batchBuild />
</workspace>
